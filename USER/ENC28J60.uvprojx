# Keil uVision project ENC28J60.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ENC28J60 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\USMART;..\HARDWARE\SPI;..\uIP-1.0;..\uIP-APP;..\HARDWARE\ENC28J60;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\ITEMP;..\LWIP-SRC\include;..\LWIP-APP\;..\LWIP-SRC\include\ipv4;..\LWIP-APP\config;..\LWIP-APP\tcp;..\LWIP-APP\udp;..\LWIP-APP\webserver;..\LWIP-APP\webserver\makefsdata;..\UCOSIII\uC-CPU;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII_Task;..\SYSTEM\mysys;..\SYSTEM\sys;..\UCOSIII_Task;..\HARDWARE\tftlcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ITEMP/: tsensor.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/tftlcd/: tftlcd.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/mysys/: mysys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group LWIP-API
    ../LWIP-SRC/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP-CORE
    ../LWIP-SRC/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../LWIP-SRC/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP-NETIF
    ../LWIP-SRC/netif/: ethernetif.c etharp.c
  group LWIP_ARCH
    ../LWIP-APP/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h sys_arch.c
  group LWIP-APP
    ../LWIP-APP/tcp/: tcp_client.c tcp_server.c
    ../LWIP-APP/config/: lwip_demo.c
    ../LWIP-APP/udp/: udp_client.c udp_server.c
    ../LWIP-APP/webserver/: fs.c httpd.c ssi_cgi_handle.c
  group LWIP-TXT
    ../../lwip-1.4.1/doc/: rawapi.txt sys_arch.txt contrib.txt savannah.txt snmp_agent.txt
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: os_app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII_Task
    ../UCOSIII_Task/: led_task.c start_task.c lwip_task.c tftlcd_task.c usart_task.c key_task.c lcdque_task.c
